## configs/nitrogen6sx_defconfig
```kconfig
CONFIG_SYS_EXTRA_OPTIONS="IMX_CONFIG=board/boundary/nitrogen6sx/imximage.cfg,MX6SX,DDR_MB=1024"
CONFIG_ARM=y
CONFIG_TARGET_NITROGEN6SX=y
```
